# Keil uVision project TouchPad_CircleGlass.uvprojx, settings and files
target STM32L152 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IGL1202-SA_APP_V30002 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32L1XX_MD,STM32L151
  c include: ..\Core;..\Lib_code\SysLib\inc;..\Lib_code\SysHard\inc;..\Lib_code\SysPower;..\Lib_code\App;..\User\Driver\USART1;..\User\Driver\USART2;..\User\Driver\WTC6216;..\User\Key;..\User\TouchPad_AirCondition;..\User\Driver\ShakeMotor;..\User\Driver\IIC;..\User\Driver\OLED;..\User\Driver\74HC595;..\User\IWDG;..\User\Driver\Queue;..\User\Driver\TIMx;..\User\Driver\EXTIx;..\User\DeviceRelate_AirCondition
  memory RVCT4: ROM 0x8006400 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Core/: system_stm32l1xx.c startup_stm32l1xx_md.s
  group SysLib
    ../Lib_code/SysLib/: BestFu_STM32L15X_L10200.lib
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
    ../Lib_code/SysPower/: ADC.c Battery.c BatteryExeAttr.c LowPower.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
  group Drive
    ../User/Driver/IIC/: IIC.c
    ../User/Driver/USART2/: USART2.c
    ../User/Driver/WTC6216/: WTC6216.c
    ../User/Driver/OLED/: OLED.c TouchPadPic.c
    ../User/Driver/74HC595/: 74HC595.c
    ../User/IWDG/: iwdg.c
    ../User/Driver/Queue/: Queue.c
    ../User/Driver/TIMx/: TIMx.c
    ../User/Driver/EXTIx/: EXTIx.c
  group Unit
    ../User/Key/: Key.c
    ../User/Driver/74HC595/: ShowLED.c
    ../User/DeviceRelate_AirCondition/: AirConditionPad.c
  group Attr
    ../User/TouchPad_AirCondition/: KeyExeAttr.c
  group Reame
    ../: Readme.txt
